# Keil uVision project Lm.uvprojx, settings and files
target IOC_V1 (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.1.0.7
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lm_V1 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, ARM_MATH_CM3,__IOC_V1__
  c misc: --exceptions
  c include: .\Include;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\lib\inc;..\..\Utilities\FatFs_R0_10b\src;..\..\Utilities\MP3;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Desktop\rapidjson-master\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./Source/: lm.cpp pyro.cpp pump.cpp fan.cpp spray.cpp ec20.cpp ee.cpp
  group Peripherals
    ./Source/: adc.cpp tim.cpp can.cpp dac.cpp isr.cpp lcd.cpp gpio.cpp
  group System
    ../lib/MDK-ARM/output/: libPfm.lib libDiscovery.lib
    ../../Libraries/DSP-Lib/CMSIS/Lib/ARM/: arm_cortexM3l_math.lib
  group Doc
    ./Include/: Doc.txt
target IOC_V2 (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.1.0.7
  cpu: as above
  output: Lm_V2 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, ARM_MATH_CM3,__IOC_V2__
  c misc: --exceptions
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target IOC_Discovery (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.1.0.7
  cpu: as above
  output: LmDiscovery +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,__DISCO__,__SIMULATION__,USE_LCD,ARM_MATH_CM3
  c misc: --exceptions
  c include: ..\lib\inc;.\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\..\Utilities\FatFs_R0_10b\src;..\..\Utilities\MP3;..\..\..\..\Desktop\rapidjson-master\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
