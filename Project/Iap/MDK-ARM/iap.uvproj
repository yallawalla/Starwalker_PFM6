# Keil uVision project iap.uvproj, settings and files
target iap...PFM6 (ARM-ADS)
  device: STM32F205VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: iapPFM +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__PFM6__,HSE_VALUE=25000000,WITH_COM_PORT
  c include: ..\;..\Inc;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\Pfm6Ctrl\inc\app;..\..\Pfm6Ctrl\src\wifi;..\..\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Main
    ../Src/: main.c
  group Serial
    ../Src/: serial.c usart.c
    ../../Pfm6Ctrl/src/app/: io.c led.c
  group stm32f10x StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_can.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_crc.c stm32f10x_flash.c misc.c
  group stm32f2xx StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_usart.c stm32f2xx_flash.c misc.c stm32f2xx_dma.c
  group Startup 103
    ../Src/: startup_stm32f10x_hd.s system_stm32f10x.c
  group Startup 205
    ../Src/: startup_stm32f2xx.s system_stm32f2xx.c
  group FatFs
    ../../FatFs/: ff.c diskio.c
    ../../FatFs/option/: ccsbcs.c
  group readme
    ./: readme.txt
target iap...PVC (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iapPVC +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=12000000,__PVC__,WITH_COM_PORT
  c include: ..\;..\Inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Pfm6Ctrl\inc\app;..\..\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target iap...Discovery (ARM-ADS)
  device: STM32F205VC STMicroelectronics
  cpu: as above
  output: iapDiscovery +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS,__DISCO__,HSE_VALUE=8000000,WITH_COM_PORT
  c include: ..\;..\Inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Pfm6Ctrl\inc\app;..\..\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
