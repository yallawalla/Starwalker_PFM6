# Keil uVision project iap.uvprojx, settings and files
target iap...PFM6 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F205VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iapPFM +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__PFM6__,HSE_VALUE=25000000,WITH_COM_PORT
  c include: ..\;..\Inc;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\Pfm6Ctrl\inc\app;..\..\Pfm6Ctrl\src\wifi;..\..\..\Utilities\FatFs_R0.09a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Main
    ../Src/: main.c
  group Serial
    ../Src/: serial.c usart.c io.c led.c
  group stm32f10x StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_can.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_crc.c stm32f10x_flash.c misc.c
  group stm32f2xx StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_usart.c stm32f2xx_flash.c misc.c stm32f2xx_dma.c
  group Startup 103
    ../Src/: startup_stm32f10x_hd.s system_stm32f10x.c
  group Startup 205
    ../Src/: startup_stm32f2xx.s system_stm32f2xx.c
  group FatFs
    ../../../Utilities/FatFs_R0.09a/: diskio.c ff.c
    ../../../Utilities/FatFs_R0.09a/option/: ccsbcs.c
  group readme
    ./: readme.txt
target iap...PVC (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iapPVC +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=12000000,__PVC__,WITH_COM_PORT
  c include: ..\;..\Inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Pfm6Ctrl\inc\app;..\..\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target iap...Discovery (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F205VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: as above
  output: iapDiscovery +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS,__DISCO__,HSE_VALUE=8000000,WITH_COM_PORT
  c include: ..\;..\Inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Pfm6Ctrl\inc\app;..\..\..\Utilities\FatFs_R0.09a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.0.0
