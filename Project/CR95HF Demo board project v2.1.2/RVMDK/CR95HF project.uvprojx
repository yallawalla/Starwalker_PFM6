# Keil uVision project CR95HF project.uvprojx, settings and files
target STM3210E_EVAL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CR95HF MMY project +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\inc;..\inc\STM32F10x_StdPeriph_Driver;..\inc\STM32_USB-FS-Device_Driver;..\inc\libraries;..\inc\drivers;..\inc\MSD;..\inc\LCD;..\STM32_Cryptographic_Library;..\STM32_Cryptographic_Library\inc;..\inc\NFC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User_Appli
    ../src/: main.c hw_config.c stm32f10x_it.c miscellaneous.c track_TAG.c
  group User_Libraries
    ../src/libraries/: lib_CR95HF.c lib_iso15693.c lib_iso14443A.c lib_iso14443B.c lib_felica.c lib_iso14443SR.c
  group User_Drivers
    ../src/drivers/: drv_uart.c drv_spi.c drv_LED.c drv_CR95HF.c
  group User_USB_Composite
    ../src/USB/: usb_desc.c usb_endp.c usb_hid.c usb_istr.c usb_prop.c usb_pwr.c
  group User_USB_MSD
    ../src/MSD/: diskio.c ff.c flash_cmd.c mass_mal.c memory.c nand_if.c scsi_data.c usb_bot.c usb_scsi.c
  group LCD_Driver
    ../src/LCD/: stm3210e_lcd.c
  group USB_FS_Driver
    ../src/USB-FS-Device_Driver/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group StdPeriph_Driver
    ../src/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_fsmc.c
  group RVMDK
    ./: startup_stm32f10x_md.s
  group CMSIS
    ../src/: core_cm3.c system_stm32f10x.c
target STM3210E_EVAL_MSD (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: CR95HF MMY project +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD, USE_STM3210E_EVAL, USE_MSD_DRIVE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
target DEMO_BOARD_CR95HF (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CR95HF MMY project +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_MB1054ABOARD
  c include: ..\inc;..\inc\STM32F10x_StdPeriph_Driver;..\inc\STM32_USB-FS-Device_Driver;..\inc\libraries;..\inc\drivers;..\inc\MSD;..\STM32_Cryptographic_Library;..\STM32_Cryptographic_Library\inc;..\inc\NFC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target DEMO_BOARD_CR95HF_MSD (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: CR95HF MMY project +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_MSD_DRIVE,USE_MB1054ABOARD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
